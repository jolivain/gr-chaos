<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>logmap_filter_demo</value></param>
<param><key>title</key><value>LogMap Filter Demo</value></param>
<param><key>author</key><value>Julien Olivain &lt;julien.olivain@lacime.etsmtl.ca&gt;</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>wxgui_histosink2</key>
<param><key>id</key><value>wxgui_histosink2_0</value></param>
<param><key>title</key><value>Histogram Plot</value></param>
<param><key>num_bins</key><value>100</value></param>
<param><key>frame_size</key><value>100000</value></param>
</block>
<block>
<key>chaos_logmap_filter_ff</key>
<param><key>id</key><value>chaos_logmap_filter_ff_0</value></param>
</block>
<block>
<key>gr_int_to_float</key>
<param><key>id</key><value>gr_int_to_float_0</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>scale</key><value>2.**31</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>file</key><value>/dev/urandom</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>wxgui_histosink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_int_to_float_0</source_block_id><sink_block_id>chaos_logmap_filter_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chaos_logmap_filter_ff_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>gr_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
